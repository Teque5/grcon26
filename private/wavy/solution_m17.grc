options:
  parameters:
    author: tq5
    generate_options: qt_gui
    id: solution
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: loop_mult
  id: variable_qtgui_entry
  parameters:
    label: loop mult
    type: real
    value: '1'
  states: {}
- name: loopbw
  id: variable_qtgui_entry
  parameters:
    label: loopbw
    type: real
    value: '.005'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '.1'
    min_freq: '-.1'
    w: '.05'
  states: {state: disabled}
- name: analog_pll_carriertracking_cc_1
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*3.14/4
    min_freq: '-2*3.14/4'
    w: loopbw
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/10)/(2.0*math.pi*800.0)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/unwavy.cf32
    type: complex
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: 70e3
    sample_rate: samp_rate
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(0.1*samp_rate/10)
    max_iter: '4000'
    scale: 1/int(0.1*samp_rate/10)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15-1
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: wavy.sigmf-data
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loopbw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loopbw
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '.00001'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '101'
    rolloff: '.1'
    samps_per_sym: '12'
    type: cc
    w: loopbw
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2.0*math.pi*0.0015*loop_mult
    max_dev: '0.05'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'True'
    debug_ctrl: 'True'
    debug_data: 'True'
    encr_type: '0'
    key: ''
    seed: ''
    signed_str: 'False'
    threshold: '2.0'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    label1: M17 baseband
    samp_per_symbol: '10'
    size: int(downsamp_rate/10)
    srate: downsamp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    label1: M17 baseband
    samp_per_symbol: '1'
    size: int(samp_rate/1000)
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/10
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(48e3/8e3)
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '80'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1.0'
    type: fir_filter_fff
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_3200
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_freqshift_cc_0, '0']
- [analog_pll_carriertracking_cc_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [analog_pll_carriertracking_cc_1, '0', blocks_freqshift_cc_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_1, '0']
- [blocks_freqshift_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_0, '1']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_sub_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_throttle2_0, '0', analog_pll_carriertracking_cc_0, '0']
- [blocks_throttle2_0, '0', analog_pll_carriertracking_cc_1, '0']
- [blocks_throttle2_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_to_vector_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_freqshift_cc_0, '0']
- [digital_costas_loop_cc_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_file_sink_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_freqshift_cc_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [digital_costas_loop_cc_0_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', m17_m17_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_eye_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_1, '0', digital_costas_loop_cc_0_0_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_0, '0']
- [m17_m17_decoder_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_eye_sink_x_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
