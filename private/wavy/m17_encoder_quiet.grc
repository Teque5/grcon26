options:
  parameters:
    author: Kyle Logue (K6OF)
    generate_options: qt_gui
    id: m17_tx
    output_language: python
    title: Simple M17 transmitter
  states: {}

blocks:
- name: audio_frequency
  id: variable_qtgui_range
  parameters:
    label: Audio frequency
    min_len: '100'
    start: '50'
    step: '1'
    stop: '1000'
    value: '440'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '480_000'
  states: {}
- name: dst
  id: variable_qtgui_entry
  parameters:
    label: Destination callsign
    type: string
    value: ALL
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: src
  id: variable_qtgui_entry
  parameters:
    label: Source callsign
    type: string
    value: K6OF
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '6000'
    gain: '1.0'
    samp_rate: '48000'
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*math.pi*800.0)/channel_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: channel_rate/(2.0*math.pi*800.0)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tq5/Projects/grcon26/private/wavy/quiet_m17_california.cf32
    type: complex
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15-1
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rf_on
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15-1
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/10
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: 48 KHz
    file: /home/tq5/Projects/grcon26/private/wavy/quiet_california.wav
    repeat: 'False'
  states: {}
- name: btn0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Stop
    msgName: pressed
    type: string
    value: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: m17_m17_coder_0_0
  id: m17_m17_coder
  parameters:
    aes_subtype: '0'
    can: '0'
    debug: 'False'
    dst_id: dst
    encr_subtype: '0'
    encr_type: '0'
    key: ''
    meta: flag 8 is 4601
    mode: '1'
    priv_key: ''
    seed: ''
    signed_str: 'False'
    src_id: src
    type: '2'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'True'
    debug_ctrl: 'True'
    debug_data: 'True'
    encr_type: '0'
    key: ''
    seed: ''
    signed_str: 'False'
    threshold: '2.0'
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    label1: M17 baseband
    samp_per_symbol: '10'
    size: '48000'
    srate: '480000'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(samp_rate*16)
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    legend: 'False'
    name: '"RF scpectrum"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    legend: 'False'
    name: '"M17 baseband"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(48e3/8e3)
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    type: ccf
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: 8 KHz
    decim: int(48e3/8e3)
    interp: '1'
    taps: taps
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    comment: upsample to 480 KHz
    gain: '1'
    interp: '100'
    ntaps: '801'
    samp_rate: '100'
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: int(freq*(1+ppm*1e-6))
    gain0: '69'
    samp_rate: samp_rate*16
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: voice_tx_packed
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: voice_rx_packed
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: voice_tx_packed
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: voice_rx_packed
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_3200
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    comment: Consumes 8 KHz
    mode: codec2.MODE_3200
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', blocks_file_sink_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', qtgui_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_eye_sink_x_0_0, '0']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_throttle2_0, '0', m17_m17_decoder_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [btn0, pressed, m17_m17_coder_0_0, end_of_transmission]
- [m17_m17_coder_0_0, '0', blocks_throttle2_0, '0']
- [m17_m17_coder_0_0, '0', root_raised_cosine_filter_0, '0']
- [m17_m17_decoder_0, '0', virtual_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_1, '0', blocks_float_to_short_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0, '0', m17_m17_coder_0_0, '0']
- [virtual_source_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
