options:
  parameters:
    generate_options: qt_gui
    id: hd_tx_am_soundcard
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: duration_s
  id: variable
  parameters:
    value: '20'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '44100'
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '127'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_interleaved_char_1
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32767'
    vector_output: 'False'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(audio_rate * 5.5)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: stargate.cf32
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/stargate.cf32
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/hdam.cs16
    type: short
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /tmp/hdam.cu8
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: /tmp/hdam.cu8
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '480000 * duration_s '
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: 'int(46511.71875 * duration_s ) '
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
    vlen: '24000'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(audio_rate * 5.5)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '44100'
    type: float
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/tq5/Projects/grcon26/private/wavy/still_alive_44100.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/tq5/Projects/grcon26/private/wavy/stargate_44100.wav
    repeat: 'True'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '256'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(256)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '4500'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    comment: send_alert.py
    mtu: '10000'
    port: '52000'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    comment: album art
    mtu: '10000'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      the nrsc5 AM decoder wants cu16 at rate=46511.71875
      python3 ~/Source/nrsc5/support/cli.py --am --iq-input-format cs16 -r /tmp/hdam.cs16 0
  states: {}
- name: nrsc5_am_pulse_shaper_0
  id: nrsc5_am_pulse_shaper
  parameters: {}
  states: {}
- name: nrsc5_hdc_encoder_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '17900'
    channels: '1'
  states: {}
- name: nrsc5_l1_am_encoder_ma1_0
  id: nrsc5_l1_am_encoder_ma1
  parameters: {}
  states: {}
- name: nrsc5_l2_encoder_0
  id: nrsc5_l2_encoder
  parameters:
    blend_control: nrsc5.blend.ENABLE
    data_bytes: '0'
    first_prog: '0'
    num_progs: '1'
    size: '3750'
  states: {}
- name: nrsc5_psd_encoder_0
  id: nrsc5_psd_encoder
  parameters:
    artist: K6OF
    bytes_per_frame: '64'
    prog_num: '0'
    title: A hi-def audio clip, not like the analog one.
  states: {}
- name: nrsc5_sis_encoder_0
  id: nrsc5_sis_encoder
  parameters:
    altitude: '93.0'
    country_code: US
    emergency_alerts: 'False'
    fcc_facility_id: '0'
    latitude: '40.6892'
    longitude: '-74.0445'
    message: Generated by GNU Radio
    mode: nrsc5.pids_mode.AM
    num_programs: '1'
    program_name0: HD1
    program_name1: HD2
    program_name2: HD3
    program_name3: HD4
    program_name4: HD5
    program_name5: HD6
    program_name6: HD7
    program_name7: HD8
    program_type0: nrsc5.program_type.NEWS
    program_type1: nrsc5.program_type.NEWS
    program_type2: nrsc5.program_type.NEWS
    program_type3: nrsc5.program_type.NEWS
    program_type4: nrsc5.program_type.NEWS
    program_type5: nrsc5.program_type.NEWS
    program_type6: nrsc5.program_type.NEWS
    program_type7: nrsc5.program_type.NEWS
    short_name: KABC
    slogan: flag{nrsc5_is_nice}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '4800'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '4800'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '128'
    interp: '135 '
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '135'
    interp: '128'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '32'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '147'
    interp: '1600'
    type: ccc
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_xx_0, '0', blocks_skiphead_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_1_0, '0']
- [blocks_complex_to_interleaved_char_1, '0', blocks_char_to_float_0, '0']
- [blocks_complex_to_interleaved_char_1, '0', blocks_file_sink_1_1, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_1, '0']
- [blocks_delay_0, '0', low_pass_filter_1, '0']
- [blocks_float_to_complex_0, '0', blocks_add_xx_0, '1']
- [blocks_head_0, '0', blocks_file_sink_0_0, '0']
- [blocks_head_0_0, '0', blocks_complex_to_interleaved_char_1, '0']
- [blocks_head_0_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_head_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_3, '0']
- [blocks_null_source_0, '0', nrsc5_l1_am_encoder_ma1_0, '1']
- [blocks_skiphead_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle2_0, '0', nrsc5_hdc_encoder_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_1, '0', blocks_delay_0, '0']
- [fft_vxx_0, '0', nrsc5_am_pulse_shaper_0, '0']
- [low_pass_filter_1, '0', blocks_add_const_vxx_0, '0']
- [network_socket_pdu_0_0, pdus, nrsc5_sis_encoder_0, command]
- [network_socket_pdu_1, pdus, nrsc5_psd_encoder_0, set_meta]
- [nrsc5_am_pulse_shaper_0, '0', rational_resampler_xxx_1, '0']
- [nrsc5_hdc_encoder_0, '0', nrsc5_l2_encoder_0, '0']
- [nrsc5_l1_am_encoder_ma1_0, '0', fft_vxx_0, '0']
- [nrsc5_l1_am_encoder_ma1_0, clock, nrsc5_psd_encoder_0, clock]
- [nrsc5_l1_am_encoder_ma1_0, clock, nrsc5_sis_encoder_0, clock]
- [nrsc5_l2_encoder_0, '0', nrsc5_l1_am_encoder_ma1_0, '0']
- [nrsc5_psd_encoder_0, '0', nrsc5_l2_encoder_0, '1']
- [nrsc5_sis_encoder_0, '0', nrsc5_l1_am_encoder_ma1_0, '2']
- [rational_resampler_xxx_0, '0', blocks_head_0_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_1, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_2, '0', blocks_complex_to_interleaved_char_0, '0']
- [rational_resampler_xxx_3, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
