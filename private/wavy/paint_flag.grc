options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: paint_tx_audio
    output_language: python
  states: {}

blocks:
- name: db_range
  id: variable
  parameters:
    value: '80'
  states: {}
- name: fft_size
  id: variable
  parameters:
    comment: Should be same as img width
    value: '1024'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: reps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1000'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/4.0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-256'
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tq5/Projects/grcon26/private/x-marks-the-spot/part/platypus.cf32
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/tq5/Projects/grcon26/private/x-marks-the-spot/part/razzle.cf32
    type: complex
  states: {state: disabled}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: fft_size
    n: fft_size * 2
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.log(10**(db_range/20)) / 256
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.018'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: reps
    type: byte
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: byte
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: exp
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: byte
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_size
    input_size: fft_size
    rolloff: fft_size
    tagname: ''
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(fft_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '0'
    image_file: /home/tq5/Projects/grcon26/private/x-marks-the-spot/img/everyone_loves_paint_edit.png
    image_flip: '1'
    image_invert: '0'
    repeatmode: '1'
  states: {state: disabled}
- name: paint_image_source_0_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '0'
    image_file: /home/tq5/Projects/grcon26/private/x-marks-the-spot/img/platypus.png
    image_flip: '1'
    image_invert: '0'
    repeatmode: '0'
  states: {}
- name: paint_image_source_0_0_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '0'
    image_file: /home/tq5/Projects/grcon26/private/x-marks-the-spot/img/razzle_platypus_edit.png
    image_flip: '1'
    image_invert: '0'
    repeatmode: '0'
  states: {state: disabled}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '1'
    width: '4096'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '4096'
    int_max: '-51'
    int_min: '-77'
    showports: 'True'
    type: float
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_magphase_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_repeat_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_repeat_1, '0']
- [blocks_transcendental_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_keep_m_in_n_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [paint_image_source_0, '0', blocks_stream_to_vector_1, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_image_source_0_0, '0', blocks_stream_to_vector_1, '0']
- [paint_image_source_0_0_0, '0', blocks_stream_to_vector_1, '0']
- [paint_paint_bc_0, '0', blocks_file_sink_0, '0']
- [paint_paint_bc_0, '0', blocks_keep_one_in_n_0, '0']
- [paint_paint_bc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [paint_paint_bc_0, '0', rational_resampler_xxx_0, '0']
- [paint_paint_bc_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
